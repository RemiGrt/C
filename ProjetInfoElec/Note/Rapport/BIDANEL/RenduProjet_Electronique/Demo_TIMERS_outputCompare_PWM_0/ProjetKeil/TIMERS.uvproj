# Keil uVision project TIMERS.uvproj, settings and files
target Target 1 (ARM-ADS)
  device: STM32F072RB STMicroelectronics
  cpu: IRAM(0x20000000-0x20003FFF) IROM(0x08000000-0x0801FFFF) CLOCK(8000000) CPUTYPE("Cortex-M0")
  output: TIMERS
  c flags: Optim=1
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x4000
  group System
    ../System/: system_stm32f0xx_SYSCLK_48MHz_GeneAvecRC_Int_8MHz.c
  group User
    ../User_Sources_Files/: main.c Adc.c
  group Startup
    ./: startup_stm32f072.s
  group Lib
    ../User_Sources_Files/: Retarget.c Serial.c
